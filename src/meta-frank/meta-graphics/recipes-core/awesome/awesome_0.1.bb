SUMMARY = "awesomewm"
DESCRIPTION = "Awesome Window Manager"
LICENSE = "MIT"


